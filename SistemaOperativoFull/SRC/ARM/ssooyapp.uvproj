# Keil uVision project ssooyapp.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ssooyapp
  c flags: Optim=1 wLevel=2
  c define: __CORTEX_M3  __CMSIS_RTOS
  c include: ..\..\SRC;..\Aplicacion\LPC1700CMSIS_Firmware_Library\include;..\Aplicacion\File\USER\FATFS_V0.08A\src;..\Aplicacion\File\USER\SPI_SD_Card;..\Aplicacion\Ethernet;..\Aplicacion\UART;..\Aplicacion\LCD;..\Aplicacion\File;..\Aplicacion\TouchPanel\USER;..\Aplicacion
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ../Aplicacion/: system_LPC17xx.c startup_LPC17xx.s
  group app
    ../Aplicacion/Other main/: main_all.c
  group Conf
    ../Aplicacion/: RTX_Conf_CM.c
  group HAL
    ./: HAL_CM3.c SVC_Table.s
    ../: HAL_CM.c
  group library
    ../: rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group Firmware library
    ../Aplicacion/LPC1700CMSIS_Firmware_Library/source/: lpc17xx_clkpwr.c lpc17xx_gpio.c lpc17xx_libcfg_default.c lpc17xx_ssp.c lpc17xx_pinsel.c debug_frmwrk.c lpc17xx_uart.c
  group UART
    ../Aplicacion/UART/: UARTn.c
  group Ethernet
    ../Aplicacion/Ethernet/: EMAC.c Ethernet.c Retarget.c tcpip.c
  group LCD
    ../Aplicacion/LCD/: LCD_SO.c font.c lcddriver.c
  group TouchPanel
    ../Aplicacion/TouchPanel/Libraries/CM3/CoreSupport/: core_cm3.c
    ../Aplicacion/TouchPanel/USER/: AsciiLib.c GLCD.c TouchPanel.c TouchPanel_OS.c
  group File
    ../Aplicacion/File/: FILE_OS.c
    ../Aplicacion/File/USER/FATFS_V0.08A/src/: ff.c diskio.c
    ../Aplicacion/File/USER/SPI_SD_Card/: SPI_MSD_Driver.c
